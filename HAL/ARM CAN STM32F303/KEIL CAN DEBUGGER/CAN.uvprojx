# Keil uVision project CAN.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F303C8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAN +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER SW_SIM=1 SIM=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source Group 1
    ./: CAN_Interface.h CAN_Private.h CAN_Program.c CAN_Types.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_sc000.h core_sc300.h main.c main.h mpu_armv7.h mpu_armv8.h startup_stm32f303c8tx.s stm32f3xx.h stm32f3xx_hal.c stm32f3xx_hal.h stm32f3xx_hal_conf.h stm32f3xx_hal_cortex.c stm32f3xx_hal_cortex.h stm32f3xx_hal_def.h stm32f3xx_hal_dma.c stm32f3xx_hal_dma.h stm32f3xx_hal_dma_ex.h stm32f3xx_hal_exti.c stm32f3xx_hal_exti.h stm32f3xx_hal_flash.c stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.c stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.c stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c.h stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2c_ex.h stm32f3xx_hal_msp.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr.h stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_pwr_ex.h stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rcc_ex.h stm32f3xx_it.c stm32f3xx_it.h stm32f3xx_ll_bus.h stm32f3xx_ll_cortex.h stm32f3xx_ll_dma.h stm32f3xx_ll_exti.h stm32f3xx_ll_gpio.h stm32f3xx_ll_pwr.h stm32f3xx_ll_rcc.h stm32f3xx_ll_system.h stm32f3xx_ll_utils.h stm32f303x8.h syscalls.c sysmem.c system_stm32f3xx.c system_stm32f3xx.h tz_context.h stat.h time.h times.h
